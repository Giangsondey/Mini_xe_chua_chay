# Keil uVision project mini_xe_chua_chay.uvprojx, settings and files
target mini_xe_chua_chay (6240000::V6.24::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: mini_xe_chua_chay +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Motor;../Flame;../Hcsr04;../Servo;../Pump;../RobotLogic;../TestHcsr04;../Delay_us;../Test_uart
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Motor
    ../Motor/: Motor.c Motor.h
  group Flame
    ../Flame/: Flame.c Flame.h
  group Hcsr04
    ../Hcsr04/: Hcsr04.c Hcsr04.h
  group Servo
    ../Servo/: Servo.c Servo.h
  group Pump
    ../Pump/: Pump.c Pump.h
  group RobotLogic
    ../RobotLogic/: RobotLogic.c RobotLogic.h
  group Delay_us
    ../Delay_us/: Delay_us.c Delay_us.h
  group Test_uart
    ../Test_uart/: Test_uart.c Test_uart.h
software components: CMSIS:CORE 6.1.1
